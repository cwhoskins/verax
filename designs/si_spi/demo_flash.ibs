[IBIS Ver] 3.2
[File Name] demo_flash.ibs
[File Rev] 1.0
[Component] DEMO_FLASH
Manufacturer verax demo (synthetic, linear tables)
[Package]
R_pkg 0.2 NA NA
L_pkg 2nH NA NA
C_pkg 0.5pF NA NA
[Pin] signal_name model_name R_pin L_pin C_pin
1 SCK  spi_in
2 MOSI spi_in
3 VCC  POWER
4 GND  GND
[Component] DEMO_FLASH_SO8B
Manufacturer verax demo (synthetic, linear tables)
[Package]
R_pkg 0.2 NA NA
L_pkg 2nH NA NA
C_pkg 0.5pF NA NA
[Pin] signal_name model_name R_pin L_pin C_pin
2 MOSI spi_in
3 VCC  POWER
4 GND  GND
[Model] spi_in
Model_type Input
C_comp 2.500000000000e-12 NA NA
Vinl = 0.8
Vinh = 2.0
[Voltage Range] 3.300000000000e+00 NA NA
[End Model]
| Models and submodels in the file (1): spi_in (Input)
